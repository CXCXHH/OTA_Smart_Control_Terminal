# Keil uVision project APP1.0.uvprojx, settings and files
target APP1.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08005000,0xB000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf.exe --bin --output ".\Objects\project.bin" ".\Objects\project.axf"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\BSP;.\BSP\Inc;.\APP;.\APP\Sensor;.\Protocol\FreeModbus;.\Middleware\Canfestival\Inc;.\Middleware\Canfestival\Inc\stm32;.\Middleware\FreeRTOS\include;.\Middleware\FreeRTOS\portable\RVDS\ARM_CM3;.\Middleware\cJSON
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_can.c stm32f10x_can.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h
  group BSP
    ./BSP/Src/: bsp.c bsp_adc.c bsp_AT24C02.c bsp_can.c bsp_gpio.c bsp_i2c_hw.c bsp_iic.c bsp_spi.c bsp_tim.c bsp_usart.c bsp_usart2.c bsp_usart3.c bsp_w25q64.c
  group User
    ./User/: main.c delay.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group APP/Sensor
    ./APP/Sensor/: aht20.c ina226.c sensor_app.c
  group APP
    ./APP/: app_tasks.c fifo.c oled.c ota.c wifi4g.c mqtt.c canopen_app.c modbus_app.c
  group Middleware/FreeRTOS
    ./Middleware/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Middleware/FreeRTOS/portable/MemMang/: heap_4.c
    ./Middleware/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Middleware/cJSON
    ./Middleware/cJSON/: cJSON.c
  group Middleware/Canfestival
    ./Middleware/Canfestival/Src/: canfestival.c lifegrd.c nmtSlave.c objacces.c pdo.c sdo.c states.c TestSlave.c timer.c
  group Protocol/FreeModbus
    ./Protocol/FreeModbus/: mb.c mbcrc.c mbrtu.c mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbutils.c portevent.c portserial.c porttimer.c
